require ${PN}-common.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

# Linux v6.1.8 + KTN patches
SRCBRANCH = "v6.1-ktn"
SRCREV = "df148b23ce08fae9f9d9d384741e0ce2b9d91ffa"
