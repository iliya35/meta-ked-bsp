IMAGE_EXTRA_INSTALL:append = " \
	spitools \
	spidev-test \
	"

IMAGE_EXTRA_INSTALL:remove = "\
	libegl-mesa \
	libgles2-mesa \
	"
