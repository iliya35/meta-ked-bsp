require ${PN}-common.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

# Linux v6.1.29 + KED patches
SRCBRANCH = "v6.1-ktn"
SRCREV = "ea91e6358937dc5a8d00f4c2adc6d5b970e60ce9"
