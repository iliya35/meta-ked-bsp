require ${PN}-common.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

# Linux v5.10.180 + KED patches
SRCBRANCH = "v5.10-ktn"
SRCREV = "aa7921f5f3b6bb8460e76fb62ba9e953d979bbb5"
