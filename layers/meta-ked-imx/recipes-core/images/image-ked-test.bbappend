IMAGE_INSTALL:append = " \
	devregs \
"
