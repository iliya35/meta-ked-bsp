FILESEXTRAPATHS:prepend = "${PN}:"
SRC_URI:append = " file://0001-Try-to-autoselect-namespace-based-on-DT-property.patch"
