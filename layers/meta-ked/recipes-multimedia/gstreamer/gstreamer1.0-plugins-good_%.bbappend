PACKAGECONFIG:append_use-mainline-bsp = " v4l2"
