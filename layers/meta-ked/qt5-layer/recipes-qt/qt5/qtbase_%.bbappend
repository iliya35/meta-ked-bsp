# Always build with framebuffer option
PACKAGECONFIG_FB = "linuxfb"
PACKAGECONFIG_DISTRO = " icu accessibility examples fontconfig"

