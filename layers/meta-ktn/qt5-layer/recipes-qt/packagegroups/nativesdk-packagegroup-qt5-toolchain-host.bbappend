# add python packages to fix gdb debugging with QtCreator 
RDEPENDS:${PN}:append = " \
    nativesdk-python3-json \
"
