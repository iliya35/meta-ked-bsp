IMAGE_INSTALL += "		\
	cinematicexperience	\
"
