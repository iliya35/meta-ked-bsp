RDEPENDS:${PN}:append = "\
    qtcreator-setup-helper-${MACHINE} \
    "
